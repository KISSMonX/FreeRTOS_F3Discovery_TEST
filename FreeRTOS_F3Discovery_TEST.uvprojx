# Keil uVision project FreeRTOS_F3Discovery_TEST.uvprojx, settings and files
target STM32F303 (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) IRAM2(0x10000000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(72000000) ELITTLE
  output: FreeRTOS_F3Discovery_TEST +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F30x_HD
  c include: .\Libraries\STM32F30x_StdPeriph_Driver\inc;.\FreeRTOS\include;.\User_Task
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group User_task
    ./User_Task/: main.c user_tasks.c
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c port.c
    ./FreeRTOS/MemMang/: heap_2.c
  group Libraries
    ./Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group ::CMSIS
    D:/Keil_v5/ARM/PACK/ARM/CMSIS/3.20.4/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group ::Device
    RTE/Device/STM32F303VC/: startup_stm32f30x.s system_stm32f30x.c
software components: CMSIS:CORE 3.20.0, CMSIS:DSP 1.4.1, Device:Startup 1.0.0
